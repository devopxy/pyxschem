** sch_path: untitled
** Generated by PyXSchem

tcleval([expr {false ? "U1 #net0 GND 3
.save I( ?1 U1 )" : "U1 #net0 GND 3 "}])
U2 #net1 #net0 1k m=1
U3 #net1 GND 1k m=1
#net3 #net2 VDD VDD pmos w=5u l=0.18u  m=1
#net2 #net2 VDD VDD pmos w=5u l=0.18u  m=1
U3 #net3 GND 1k m=1
U3 #net2 GND 1k m=1
